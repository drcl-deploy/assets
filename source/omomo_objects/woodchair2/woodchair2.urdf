Commit message: renamed drcl-woodchair

File: source/omomo_objects/woodchair2/woodchair2.urdf (robot description, URDF)
Before this commit: robot drcl-woodchair, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=woodchair2.obj; visual mesh filename=woodchair2.obj
